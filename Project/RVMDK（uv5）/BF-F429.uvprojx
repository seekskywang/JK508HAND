# Keil uVision project BF-F429.uvprojx, settings and files
target LCD (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LCD +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ..\..\Output\update.bin ..\..\Output\LCD.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_USB_OTG_FS
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\User\APP;..\..\User\FATFS;..\..\USBD_FS_HID;..\..\USBD_FS_Lib\USBD_inc;..\..\User\sd_spi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group DOC
    ../../: 必读说明.txt
  group APP
    ../../User/APP/: home.c system.c settings.c separation.c sysinfo.c graph.c graphset.c history.c calibarate.c power_on.c factory.c
  group USBD/FS/Lib
    ../../USBD_FS_Lib/USBD-src/: usb_core.c usb_dcd.c usb_dcd_int.c usbd_core.c usbd_ioreq.c usbd_req.c
  group USBD/FS/HID
    ../../USBD_FS_HID/: usbd_usr.c usbd_hid_core.c usbd_desc.c usb_bsp.c
  group FatFs
    ../../User/FATFS/: diskio.c ff.c
    ../../User/FATFS/option/: cc936.c
  group USER
    ../../User/: main.c flash_if.c fileoperate.c stm32f4xx_it.c touchscreen.c
    ../../User/sdram/: bsp_sdram.c
    ../../User/lcd/: bsp_lcd.c
    ../../User/usart/: bsp_debug_usart.c
    ../../User/flash/: bsp_spi_flash.c
    ../../User/key/: bsp_key.c
    ../../User/systick/: bsp_SysTick.c
    ../../User/beep/: bsp_beep.c
    ../../User/tim/: bsp_basic_tim.c
    ../../User/RTC/: bsp_rtc.c
    ../../User/internalFlash/: bsp_internalFlash.c
    ../../User/ch376/: ch376.c
    ../../User/FILESYS/: FILESYS.c
    ../../User/sdio/: bsp_sdio_sd.c
    ../../User/font/: fonts.c
